# Keil uVision project VE21_CAN.uvprojx, settings and files
target VE21 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: FM33LG02X FMSH
  pack: FMSH.FM33LG0XX_DFP.3.0.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: VE21_CAN
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\FM33LG0xx_FL_Driver\Inc;.\CMSIS\Inculde;.\CMSIS\Device\FM\FM33xx\Include;.\DRV;.\APP;.\HAL_FM33LG0XX;.\ComStack\Can_Gen;.\ComStack\Can_Gen\Can;.\ComStack\Can_Gen\CanIf;.\ComStack\Can_Gen\CanTp;.\ComStack\Can_Gen\Com;.\ComStack\Can_Gen\Dcm;.\ComStack\CanDriver;.\ComStack\CanInterface;.\ComStack\CanInterface\Dem;.\ComStack\CanInterface\Det;.\ComStack\CanTp;.\ComStack\CanTrcv;.\ComStack\Ccp;.\ComStack\Com;.\ComStack\Common;.\ComStack\Dcm;.\ComStack\OsekNm;.\ComStack\PDUR;.\ComStack;.\User_code\drv\Event;.\User_code\drv\EE_Flash;.\User_code\drv\Memory
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group APP
    ./APP/: app_button.c app_crc8.c app_led.c app_system_voltage.c app_adc.c app_pwm.c app_can.c app_demm.c
  group DRV
    ./DRV/drv_button/: drv_button.c
    ./DRV/drv_crc8/: drv_crc8.c
    ./DRV/drv_system_voltage/: drv_system_voltage.c
    ./DRV/drv_led/: drv_led.c
    ./DRV/drv_adc/: drv_adc.c
  group HAL
    ./HAL_FM33LG0XX/hal_gpio/: hal_gpio.c
    ./HAL_FM33LG0XX/hal_tick/: hal_tick.c
    ./HAL_FM33LG0XX/hal_adc/: hal_adc.c
    ./HAL_FM33LG0XX/hal_time/: hal_time.c
    ./HAL_FM33LG0XX/hal_pwm/: hal_pwm.c
  group CMSIS
    ./CMSIS/Device/FM/FM33xx/Source/: system_fm33lg0xx.c
    ./CMSIS/Device/FM/FM33xx/Source/Templates/ARM/: startup_fm33lg0xx.s
    ./CMSIS/Device/FM/FM33xx/Include/: fm33lg0xx.h system_fm33lg0xx.h
  group FM33LG0xx_FL_Driver
    ./FM33LG0xx_FL_Driver/Src/: fm33lg0xx_fl.c fm33lg0xx_fl_adc.c fm33lg0xx_fl_aes.c fm33lg0xx_fl_atim.c fm33lg0xx_fl_bstim16.c fm33lg0xx_fl_bstim32.c fm33lg0xx_fl_can.c fm33lg0xx_fl_cmu.c fm33lg0xx_fl_comp.c fm33lg0xx_fl_crc.c fm33lg0xx_fl_dac.c fm33lg0xx_fl_divas.c fm33lg0xx_fl_dma.c fm33lg0xx_fl_exti.c fm33lg0xx_fl_flash.c fm33lg0xx_fl_gpio.c fm33lg0xx_fl_gptim.c fm33lg0xx_fl_i2c.c fm33lg0xx_fl_iwdt.c fm33lg0xx_fl_lcd.c fm33lg0xx_fl_lptim16.c fm33lg0xx_fl_lptim32.c fm33lg0xx_fl_lpuart.c fm33lg0xx_fl_pmu.c fm33lg0xx_fl_rng.c fm33lg0xx_fl_rtca.c fm33lg0xx_fl_spi.c fm33lg0xx_fl_svd.c fm33lg0xx_fl_uart.c fm33lg0xx_fl_vao.c fm33lg0xx_fl_vrefp.c fm33lg0xx_fl_wwdt.c
  group User_code
    ./User_code/: main.c
    ./User_code/drv/Event/: Event.c
    ./User_code/drv/EE_Flash/: eeprom.c eeprom_cfg.c
    ./User_code/drv/Memory/: Memory.c
  group ComStack
    ./ComStack/Can_Gen/Com/: App_Com.c Com_Lcfg.c Com_Cfg.c
    ./ComStack/Can_Gen/Dcm/: App_Dcm.c Dcm_Lcfg.c Dcm_Cfg.c
    ./ComStack/Ccp/: App_Ccp.c Ccp.c Ccp_Cfg.c
    ./ComStack/OsekNm/: OsekNm_App.c OsekNm.c OsekNm_Cfg.c
    ./ComStack/Can_Gen/Can/: Can_PBcfg.c
    ./ComStack/Can_Gen/CanIf/: CanIf_Lcfg.c
    ./ComStack/Can_Gen/CanTp/: CanTp_PBcfg.c
    ./ComStack/CanDriver/: Can.c Can_Cbk.c
    ./ComStack/CanInterface/: CanIf.c
    ./ComStack/CanInterface/Dem/: Dem.c Dem_Cfg.c Demm.c
    ./ComStack/CanInterface/Det/: Det.c
    ./ComStack/CanTp/: CanTp.c
    ./ComStack/CanTrcv/: CanTrcv.c
    ./ComStack/Com/: Com.c
    ./ComStack/Dcm/: Dcm.c Dcm_Cbk.c
    ./ComStack/PDUR/: PduR.c
  group ComStack_H
    ./ComStack/Can_Gen/CanTp/: CanTp_Cfg.h
    ./ComStack/Can_Gen/CanIf/: CanIf_Cfg.h
    ./ComStack/Can_Gen/Can/: Can_Cfg.h
    ./ComStack/Can_Gen/Com/: Com_Cfg.h
    ./ComStack/Can_Gen/Dcm/: Dcm_Cfg.h
    ./ComStack/CanDriver/: Can.h Can_Pl.h Can_Type.h
    ./ComStack/CanInterface/Dem/: Dem.h Dem_Cfg.h Dem_IntErrId.h Dem_Types.h demm.h
    ./ComStack/CanInterface/Det/: Det.h
    ./ComStack/CanInterface/: CanIf.h CanIf_Cbk.h CanIf_Type.h
    ./ComStack/CanTp/: CanTp.h CanTp_Cbk.h
    ./ComStack/CanTrcv/: CanTrcv.h
    ./ComStack/Ccp/: Ccp.h Ccp_Cfg.h
    ./ComStack/Com/: Com.h Com_Cbk.h Com_Types.h
    ./ComStack/Common/: Compiler.h Compiler_Cfg.h ComStack_Types.h MemMap.h Platform_Types.h Std_Types.h
    ./ComStack/Dcm/: Dcm.h Dcm_Cbk.h Dcm_Types.h
    ./ComStack/OsekNm/: OsekNm.h OsekNm_Cfg.h
    ./ComStack/PDUR/: PduR.h PduR_CanTp.h PduR_Cfg.h PduR_Dcm.h PduR_Types.h
